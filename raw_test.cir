*

x6c93 33cc 5f5f  t1 6c93_0 LSmitll_XOR_opt
xjtl1  6c93_0 6c93_1 LSMITLL_jtl
xjtl5  6c93_1 6c93   LSMITLL_jtl
x936c  6c93      t2 936c LSMITLL_NOT_opt

ROUT_936c 936c  0   1
.print DEVI ROUT_936c

I33cc 0 33cc pwl(0 0 2.97e-10 0 3e-10 0.0005 3.03e-10 0 7.97e-10 0 8e-10 0.0005 8.03e-10 0 1.297e-09 0 1.3e-09 0.0005 1.303e-09 0 1.797e-09 0 1.8e-09 0.0005 1.803e-09 0 2.297e-09 0 2.3e-09 0.0005 2.303e-09 0 2.797e-09 0 2.8e-09 0.0005 2.803e-09 0 3.297e-09 0 3.3e-09 0.0005 3.303e-09 0 3.797e-09 0 3.8e-09 0.0005 3.803e-09 0 4.297e-09 0 4.3e-09 0.0005 4.303e-09 0 4.797e-09 0 4.8e-09 0.0005 4.803e-09 0 5.297e-09 0 5.3e-09 0.0005 5.303e-09 0 5.797e-09 0 5.8e-09 0.0005 5.803e-09 0 6.297e-09 0 6.3e-09 0.0005 6.303e-09 0 6.797e-09 0 6.8e-09 0.0005 6.803e-09 0 7.297e-09 0 7.3e-09 0.0005 7.303e-09 0 7.797e-09 0 7.8e-09 0.0005 7.803e-09 0)

I5f5f 0 5f5f pwl(0 0 5.97e-10 0 6e-10 0.0005 6.03e-10 0 8.47e-10 0 8.5e-10 0.0005 8.53e-10 0 1.597e-09 0 1.6e-09 0.0005 1.603e-09 0 1.847e-09 0 1.85e-09 0.0005 1.853e-09 0 2.597e-09 0 2.6e-09 0.0005 2.603e-09 0 2.847e-09 0 2.85e-09 0.0005 2.853e-09 0 3.597e-09 0 3.6e-09 0.0005 3.603e-09 0 3.847e-09 0 3.85e-09 0.0005 3.853e-09 0 4.597e-09 0 4.6e-09 0.0005 4.603e-09 0 4.847e-09 0 4.85e-09 0.0005 4.853e-09 0 5.597e-09 0 5.6e-09 0.0005 5.603e-09 0 5.847e-09 0 5.85e-09 0.0005 5.853e-09 0 6.597e-09 0 6.6e-09 0.0005 6.603e-09 0 6.847e-09 0 6.85e-09 0.0005 6.853e-09 0 7.597e-09 0 7.6e-09 0.0005 7.603e-09 0 7.847e-09 0 7.85e-09 0.0005 7.853e-09 0)

It1 0    t1  pwl(0 0  2.4700000000000003e-10 0 2.5e-10 0.0005 2.53e-10 0 4.97e-10 0 5e-10 0.0005 5.03e-10 0 7.470000000000001e-10 0 7.500000000000001e-10 0.0005 7.530000000000001e-10 0 9.97e-10 0 1e-09 0.0005 1.0030000000000002e-09 0 1.247e-09 0 1.25e-09 0.0005 1.2530000000000001e-09 0 1.4970000000000001e-09 0 1.5000000000000002e-09 0.0005 1.5030000000000003e-09 0 1.747e-09 0 1.7500000000000002e-09 0.0005 1.7530000000000003e-09 0 1.997e-09 0 2e-09 0.0005 2.0030000000000002e-09 0 2.247e-09 0 2.2500000000000003e-09 0.0005 2.2530000000000004e-09 0 2.497e-09 0 2.5e-09 0.0005 2.503e-09 0 2.747e-09 0 2.7500000000000002e-09 0.0005 2.7530000000000003e-09 0 2.9970000000000003e-09 0 3.0000000000000004e-09 0.0005 3.0030000000000005e-09 0 3.247e-09 0 3.25e-09 0.0005 3.2530000000000002e-09 0 3.4970000000000002e-09 0 3.5000000000000003e-09 0.0005 3.5030000000000004e-09 0 3.747e-09 0 3.7500000000000005e-09 0.0005 3.7530000000000006e-09 0 3.997e-09 0 4e-09 0.0005 4.003e-09 0 4.247e-09 0 4.25e-09 0.0005 4.253e-09 0 4.4970000000000005e-09 0 4.500000000000001e-09 0.0005 4.503000000000001e-09 0 4.747e-09 0 4.75e-09 0.0005 4.7530000000000004e-09 0 4.997e-09 0 5e-09 0.0005 5.003e-09 0 5.247000000000001e-09 0 5.250000000000001e-09 0.0005 5.253000000000001e-09 0 5.497e-09 0 5.5000000000000004e-09 0.0005 5.5030000000000005e-09 0 5.747e-09 0 5.75e-09 0.0005 5.753e-09 0 5.997000000000001e-09 0 6.000000000000001e-09 0.0005 6.003000000000001e-09 0 6.2470000000000005e-09 0 6.2500000000000005e-09 0.0005 6.253000000000001e-09 0 6.497e-09 0 6.5e-09 0.0005 6.503e-09 0 6.747e-09 0 6.75e-09 0.0005 6.753e-09 0 6.9970000000000005e-09 0 7.000000000000001e-09 0.0005 7.003000000000001e-09 0 7.247e-09 0 7.25e-09 0.0005 7.2530000000000005e-09 0 7.497000000000001e-09 0 7.500000000000001e-09 0.0005 7.503000000000001e-09 0 7.747e-09 0 7.75e-09 0.0005 7.753e-09 0 7.997e-09 0 8e-09 0.0005 8.003e-09 0 )
.print DEVI It1

It2 0    t2  pwl(0 0  2.4700000000000003e-10 0 2.5e-10 0.0005 2.53e-10 0 4.97e-10 0 5e-10 0.0005 5.03e-10 0 7.470000000000001e-10 0 7.500000000000001e-10 0.0005 7.530000000000001e-10 0 9.97e-10 0 1e-09 0.0005 1.0030000000000002e-09 0 1.247e-09 0 1.25e-09 0.0005 1.2530000000000001e-09 0 1.4970000000000001e-09 0 1.5000000000000002e-09 0.0005 1.5030000000000003e-09 0 1.747e-09 0 1.7500000000000002e-09 0.0005 1.7530000000000003e-09 0 1.997e-09 0 2e-09 0.0005 2.0030000000000002e-09 0 2.247e-09 0 2.2500000000000003e-09 0.0005 2.2530000000000004e-09 0 2.497e-09 0 2.5e-09 0.0005 2.503e-09 0 2.747e-09 0 2.7500000000000002e-09 0.0005 2.7530000000000003e-09 0 2.9970000000000003e-09 0 3.0000000000000004e-09 0.0005 3.0030000000000005e-09 0 3.247e-09 0 3.25e-09 0.0005 3.2530000000000002e-09 0 3.4970000000000002e-09 0 3.5000000000000003e-09 0.0005 3.5030000000000004e-09 0 3.747e-09 0 3.7500000000000005e-09 0.0005 3.7530000000000006e-09 0 3.997e-09 0 4e-09 0.0005 4.003e-09 0 4.247e-09 0 4.25e-09 0.0005 4.253e-09 0 4.4970000000000005e-09 0 4.500000000000001e-09 0.0005 4.503000000000001e-09 0 4.747e-09 0 4.75e-09 0.0005 4.7530000000000004e-09 0 4.997e-09 0 5e-09 0.0005 5.003e-09 0 5.247000000000001e-09 0 5.250000000000001e-09 0.0005 5.253000000000001e-09 0 5.497e-09 0 5.5000000000000004e-09 0.0005 5.5030000000000005e-09 0 5.747e-09 0 5.75e-09 0.0005 5.753e-09 0 5.997000000000001e-09 0 6.000000000000001e-09 0.0005 6.003000000000001e-09 0 6.2470000000000005e-09 0 6.2500000000000005e-09 0.0005 6.253000000000001e-09 0 6.497e-09 0 6.5e-09 0.0005 6.503e-09 0 6.747e-09 0 6.75e-09 0.0005 6.753e-09 0 6.9970000000000005e-09 0 7.000000000000001e-09 0.0005 7.003000000000001e-09 0 7.247e-09 0 7.25e-09 0.0005 7.2530000000000005e-09 0 7.497000000000001e-09 0 7.500000000000001e-09 0.0005 7.503000000000001e-09 0 7.747e-09 0 7.75e-09 0.0005 7.753e-09 0 7.997e-09 0 8e-09 0.0005 8.003e-09 0 )
.print DEVI It2

.print DEVI I33cc
.print DEVI I5f5f
.print V 33cc
.print V 5f5f
.print V 6c93_0
.print V 6c93
.print V 936c

.tran 1e-12 8.250000000000001e-09

.end
