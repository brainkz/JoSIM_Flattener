*
I0 0 10  PULSE(0 0.0006 1e-11 2e-12 2e-12 1e-12 2e-11)
I1 0 11  PWL(0 0 5.5e-11 0 5.8e-11 0.001 6.1e-11 0 2e-10 0 2.03e-10 0.001 2.06e-10 0 2.1e-10 0)
R0 7 0  2
T1 2 0 3 0  Z0=5 TD=1e-11
T2 9 0 4 0  Z0=5 TD=1e-11
T3 5 0 6 0  Z0=5 TD=1e-11
B01RX1|0 10|0 32|0 JMITLL AREA=0.7938328024901055
B01RX2|0 4|0 18|0 JMITLL AREA=0.9061035220612258
B01TX1|0 15|0 47|0 JMITLL AREA=3.027086604268269
B02RX2|0 5|0 21|0 JMITLL AREA=0.9637658214414866
B1|0 11|0 35|0 JMITLL AREA=1.4277751453682372
B2|0 8|0 9|0 JMITLL AREA=1.4987454889402436
B3|0 12|0 38|0 JMITLL AREA=0.9602271459863292
B4|0 13|0 41|0 JMITLL AREA=1.6952020313450789
B5|0 7|0 13|0 JMITLL AREA=1.1734522448720066
B6|0 6|0 24|0 JMITLL AREA=1.3640447384085008
B7|0 14|0 44|0 JMITLL AREA=1.4999656477674999
IB01RX1|0 0 34|0  PWL(0 0 5e-12 0.00011545625675287277)
IB01RX2|0 0 20|0  PWL(0 0 5e-12 0.00010188913593562593)
IB01TX1|0 0 46|0  PWL(0 0 5e-12 0.00018140292212037875)
IB1|0 0 37|0  PWL(0 0 5e-12 0.00012040154933150344)
IB2|0 0 40|0  PWL(0 0 5e-12 6.347858159093747e-05)
IB3|0 0 43|0  PWL(0 0 5e-12 0.00015363347549359588)
IB4|0 0 23|0  PWL(0 0 5e-12 0.0001617296221156164)
L01RX1|0 4 10|0  1.4066532862604666e-12
L01RX2|0 3 4|0  1.2310168079514995e-12
L02RX1|0 10|0 27|0  3.2946658347639157e-12
L02RX2|0 4|0 16|0  2.4403564820406232e-12
L02TX1|0 15|0 31|0  1.804008602901138e-12
L03RX2|0 16|0 5|0  3.649437369463691e-12
L1|0 27|0 11|0  1.1284513693561857e-12
L2A|0 11|0 28|0  5.40282982300358e-13
L2B|0 28|0 8|0  1.6028916111527104e-12
L3|0 12|0 29|0  9.453744039701024e-13
L3A|0 9|0 12|0  1.1141430616098756e-12
L4|0 29|0 13|0  4.44008649731592e-12
L5A|0 13|0 30|0  3.6349389291208616e-12
L5B|0 30|0 14|0  5.939354402373924e-13
L6|0 14|0 15|0  1.323271380268522e-12
L7|0 6|0 7|0  1.907903028464016e-12
L8|0 5|0 6|0  1.7976360392814265e-12
LIB01TX1|0 15|0 46|0  2e-13
LIB2|0 29|0 40|0  2e-13
LIB3|0 30|0 43|0  2e-13
LP01RX1|0 32|0 0  3.4e-13
LP01RX2|0 18|0 0  3.4e-13
LP01TX1|0 47|0 0  5e-14
LP02RX2|0 21|0 0  6e-14
LP1|0 35|0 0  2e-13
LP3|0 38|0 0  2e-13
LP4|0 41|0 0  2e-13
LP6|0 24|0 0  2e-13
LPB7|0 44|0 0  2e-13
LPIB1|0 28|0 37|0  2e-13
LPIB4|0 6|0 23|0  2e-13
LPR01RX1|0 27|0 34|0  2e-13
LPR01RX2|0 16|0 20|0  2e-13
LRB01RX1|0 33|0 0  9.764892516439718e-12
LRB01RX2|0 19|0 0  8.5549739114867e-12
LRB01TX1|0 48|0 0  2.56077641829273e-12
LRB02RX2|0 22|0 0  8.043128133290656e-12
LRB1|0 36|0 0  5.429210627098262e-12
LRB2|0 26|0 9|0  5.1721203163194755e-12
LRB3|0 39|0 0  8.0727690575521e-12
LRB4|0 42|0 0  4.572724577370477e-12
LRB5|0 25|0 13|0  6.605886201347298e-12
LRB6|0 17|0 0  5.682872250498387e-12
LRB7|0 45|0 0  5.167913014459609e-12
RB01RX1|0 10|0 33|0  17.282995604318085
RB01RX2|0 4|0 19|0  15.141546745994159
RB01TX1|0 15|0 48|0  4.532347642995982
RB02RX2|0 5|0 22|0  14.235625014673728
RB1|0 11|0 36|0  9.609222348846481
RB2|0 8|0 26|0  9.154195250122966
RB3|0 12|0 39|0  14.288086827525838
RB4|0 13|0 42|0  8.093317836053942
RB5|0 7|0 25|0  11.691833984685484
RB6|0 6|0 17|0  10.058180974333428
RB7|0 14|0 45|0  9.1467486981586
RINSTX1|0 31|0 5  1.36
B0|1 3|1 4|1 JJMIT AREA=2.25
B1|1 5|1 10|1 JJMIT AREA=2.25
B2|1 6|1 12|1 JJMIT AREA=2.5
I0|1 0 7|1  PWL(0 0 5e-12 0.000275)
I1|1 0 8|1  PWL(0 0 5e-12 0.000175)
L0|1 7|1 4|1  2e-13
L1|1 8|1 6|1  2e-13
L2|1 10 9|1  1e-12
L3|1 9|1 3|1  6e-13
L4|1 4|1 5|1  1.1e-12
L5|1 5|1 6|1  4.5e-12
L6|1 6|1 1  2e-12
L7|1 9|1 0  3.9e-12
L8|1 14|1 4|1  1e-12
L9|1 10|1 0  2e-13
L10|1 11|1 0  1e-12
L11|1 12|1 0  2e-13
L12|1 13|1 0  1e-12
R0|1 5|1 11|1  3.048846408
R1|1 6|1 13|1  2.743961767
R2|1 3|1 14|1  3.048846408
B0|2 3|2 8|2 JJMIT AREA=2
B1|2 4|2 10|2 JJMIT AREA=1.62
I0|2 0 5|2  PWL(0 0 5e-12 0.00023)
I1|2 0 6|2  PWL(0 0 5e-12 8.2e-05)
L0|2 5|2 3|2  2e-13
L1|2 6|2 4|2  1.3e-12
L2|2 1 3|2  2.5e-12
L3|2 3|2 4|2  3.3e-12
L4|2 4|2 7|2  3.5e-13
L5|2 8|2 0  5e-14
L6|2 9|2 0  1e-12
L7|2 10|2 0  1.2e-13
L8|2 11|2 0  1e-12
R0|2 7|2 2  1.36
R1|2 3|2 9|2  4.85
R2|2 4|2 11|2  6.3
B0|3 3|3 8|3 JJMIT AREA=1
B1|3 4|3 10|3 JJMIT AREA=1
B2|3 5|3 12|3 JJMIT AREA=1
I0|3 0 6|3  PWL(0 0 5e-12 0.000155)
L0|3 6|3 7|3  2e-13
L1|3 6 3|3  2e-13
L2|3 3|3 7|3  4.3e-12
L3|3 7|3 4|3  4.6e-12
L4|3 4|3 5|3  5e-12
L5|3 5|3 7  2.3e-12
L6|3 8|3 0  3.4e-13
L7|3 9|3 0  5e-13
L8|3 10|3 0  6e-14
L9|3 11|3 0  1e-12
L10|3 12|3 0  3e-14
L11|3 13|3 0  1e-12
R0|3 3|3 9|3  6.859904418
R1|3 4|3 11|3  6.859904418
R2|3 5|3 13|3  6.859904418
B0|4 3|4 4|4 JJMIT AREA=2.25
B1|4 5|4 10|4 JJMIT AREA=2.25
B2|4 6|4 12|4 JJMIT AREA=2.5
I0|4 0 7|4  PWL(0 0 5e-12 0.000275)
I1|4 0 8|4  PWL(0 0 5e-12 0.000175)
L0|4 7|4 4|4  2e-13
L1|4 8|4 6|4  2e-13
L2|4 11 9|4  1e-12
L3|4 9|4 3|4  6e-13
L4|4 4|4 5|4  1.1e-12
L5|4 5|4 6|4  4.5e-12
L6|4 6|4 8  2e-12
L7|4 9|4 0  3.9e-12
L8|4 14|4 4|4  1e-12
L9|4 10|4 0  2e-13
L10|4 11|4 0  1e-12
L11|4 12|4 0  2e-13
L12|4 13|4 0  1e-12
R0|4 5|4 11|4  3.048846408
R1|4 6|4 13|4  2.743961767
R2|4 3|4 14|4  3.048846408
B0|5 3|5 8|5 JJMIT AREA=2
B1|5 4|5 10|5 JJMIT AREA=1.62
I0|5 0 5|5  PWL(0 0 5e-12 0.00023)
I1|5 0 6|5  PWL(0 0 5e-12 8.2e-05)
L0|5 5|5 3|5  2e-13
L1|5 6|5 4|5  1.3e-12
L2|5 8 3|5  2.5e-12
L3|5 3|5 4|5  3.3e-12
L4|5 4|5 7|5  3.5e-13
L5|5 8|5 0  5e-14
L6|5 9|5 0  1e-12
L7|5 10|5 0  1.2e-13
L8|5 11|5 0  1e-12
R0|5 7|5 9  1.36
R1|5 3|5 9|5  4.85
R2|5 4|5 11|5  6.3
.TRAN 0.25P 600P 0 0.25P UIC
.MODEL JJMIT JJ(RTYPE=1, VG=2.6MV, CAP=0.07PF, R0=160, RN=16, ICRIT=0.1MA)
.MODEL JMITLL JJ(RTYPE=1, VG=2.6MV, CAP=0.07PF, R0=160, RN=16, ICRIT=0.1MA)
.PLOT V(4) V(3) V(5)
